#include "ssd1306.h"
#include <string.h>

static I2C_HandleTypeDef *oled_i2c;

/* Framebuffer: 128x64 bits = 1024 bytes */
static uint8_t SSD1306_Buffer[SSD1306_WIDTH * SSD1306_HEIGHT / 8];
static uint8_t cursorX = 0;
static uint8_t cursorY = 0;

/* 6x8 Font Data (ASCII 32 - 127) */
static const uint8_t Font6x8[96][6] = {
    /* ASCII 32–47 */
    {0x00,0x00,0x00,0x00,0x00,0x00}, // ' '
    {0x00,0x00,0x5F,0x00,0x00,0x00}, // !
    {0x00,0x07,0x00,0x07,0x00,0x00}, // "
    {0x14,0x7F,0x14,0x7F,0x14,0x00}, // #
    {0x24,0x2A,0x7F,0x2A,0x12,0x00}, // $
    {0x23,0x13,0x08,0x64,0x62,0x00}, // %
    {0x36,0x49,0x55,0x22,0x50,0x00}, // &
    {0x00,0x05,0x03,0x00,0x00,0x00}, // '
    {0x00,0x1C,0x22,0x41,0x00,0x00}, // (
    {0x00,0x41,0x22,0x1C,0x00,0x00}, // )
    {0x14,0x08,0x3E,0x08,0x14,0x00}, // *
    {0x08,0x08,0x3E,0x08,0x08,0x00}, // +
    {0x00,0x50,0x30,0x00,0x00,0x00}, // ,
    {0x08,0x08,0x08,0x08,0x08,0x00}, // -
    {0x00,0x60,0x60,0x00,0x00,0x00}, // .
    {0x20,0x10,0x08,0x04,0x02,0x00}, // /

    /* ASCII 48–57 (0–9) */
    {0x3E,0x51,0x49,0x45,0x3E,0x00}, // 0
    {0x00,0x42,0x7F,0x40,0x00,0x00}, // 1
    {0x42,0x61,0x51,0x49,0x46,0x00}, // 2
    {0x21,0x41,0x45,0x4B,0x31,0x00}, // 3
    {0x18,0x14,0x12,0x7F,0x10,0x00}, // 4
    {0x27,0x45,0x45,0x45,0x39,0x00}, // 5
    {0x3C,0x4A,0x49,0x49,0x30,0x00}, // 6
    {0x01,0x71,0x09,0x05,0x03,0x00}, // 7
    {0x36,0x49,0x49,0x49,0x36,0x00}, // 8
    {0x06,0x49,0x49,0x29,0x1E,0x00}, // 9

    /* ASCII 58–64 */
    {0x00,0x36,0x36,0x00,0x00,0x00}, // :
    {0x00,0x56,0x36,0x00,0x00,0x00}, // ;
    {0x08,0x14,0x22,0x41,0x00,0x00}, // <
    {0x14,0x14,0x14,0x14,0x14,0x00}, // =
    {0x00,0x41,0x22,0x14,0x08,0x00}, // >
    {0x02,0x01,0x51,0x09,0x06,0x00}, // ?
    {0x32,0x49,0x79,0x41,0x3E,0x00}, // @

    /* ASCII 65–90 (A–Z) */
    {0x7E,0x11,0x11,0x11,0x7E,0x00}, // A
    {0x7F,0x49,0x49,0x49,0x36,0x00}, // B
    {0x3E,0x41,0x41,0x41,0x22,0x00}, // C
    {0x7F,0x41,0x41,0x22,0x1C,0x00}, // D
    {0x7F,0x49,0x49,0x49,0x41,0x00}, // E
    {0x7F,0x09,0x09,0x09,0x01,0x00}, // F
    {0x3E,0x41,0x49,0x49,0x7A,0x00}, // G
    {0x7F,0x08,0x08,0x08,0x7F,0x00}, // H
    {0x00,0x41,0x7F,0x41,0x00,0x00}, // I
    {0x20,0x40,0x41,0x3F,0x01,0x00}, // J
    {0x7F,0x08,0x14,0x22,0x41,0x00}, // K
    {0x7F,0x40,0x40,0x40,0x40,0x00}, // L
    {0x7F,0x02,0x0C,0x02,0x7F,0x00}, // M
    {0x7F,0x04,0x08,0x10,0x7F,0x00}, // N
    {0x3E,0x41,0x41,0x41,0x3E,0x00}, // O
    {0x7F,0x09,0x09,0x09,0x06,0x00}, // P
    {0x3E,0x41,0x51,0x21,0x5E,0x00}, // Q
    {0x7F,0x09,0x19,0x29,0x46,0x00}, // R
    {0x46,0x49,0x49,0x49,0x31,0x00}, // S
    {0x01,0x01,0x7F,0x01,0x01,0x00}, // T
    {0x3F,0x40,0x40,0x40,0x3F,0x00}, // U
    {0x1F,0x20,0x40,0x20,0x1F,0x00}, // V
    {0x7F,0x20,0x18,0x20,0x7F,0x00}, // W
    {0x63,0x14,0x08,0x14,0x63,0x00}, // X
    {0x07,0x08,0x70,0x08,0x07,0x00}, // Y
    {0x61,0x51,0x49,0x45,0x43,0x00}, // Z

    /* ASCII 91–96 */
    {0x00,0x7F,0x41,0x41,0x00,0x00}, // [
    {0x02,0x04,0x08,0x10,0x20,0x00}, // \
    {0x00,0x41,0x41,0x7F,0x00,0x00}, // ]
    {0x04,0x02,0x01,0x02,0x04,0x00}, // ^
    {0x40,0x40,0x40,0x40,0x40,0x00}, // _
    {0x00,0x01,0x02,0x04,0x00,0x00}, // `

    /* ASCII 97–122 (a–z) */
    {0x20,0x54,0x54,0x54,0x78,0x00}, // a
    {0x7F,0x48,0x44,0x44,0x38,0x00}, // b
    {0x38,0x44,0x44,0x44,0x20,0x00}, // c
    {0x38,0x44,0x44,0x48,0x7F,0x00}, // d
    {0x38,0x54,0x54,0x54,0x18,0x00}, // e
    {0x08,0x7E,0x09,0x01,0x02,0x00}, // f
    {0x0C,0x52,0x52,0x52,0x3E,0x00}, // g
    {0x7F,0x08,0x04,0x04,0x78,0x00}, // h
    {0x00,0x44,0x7D,0x40,0x00,0x00}, // i
    {0x20,0x40,0x44,0x3D,0x00,0x00}, // j
    {0x7F,0x10,0x28,0x44,0x00,0x00}, // k
    {0x00,0x41,0x7F,0x40,0x00,0x00}, // l
    {0x7C,0x04,0x18,0x04,0x78,0x00}, // m
    {0x7C,0x08,0x04,0x04,0x78,0x00}, // n
    {0x38,0x44,0x44,0x44,0x38,0x00}, // o
    {0x7C,0x14,0x14,0x14,0x08,0x00}, // p
    {0x08,0x14,0x14,0x18,0x7C,0x00}, // q
    {0x7C,0x08,0x04,0x04,0x08,0x00}, // r
    {0x48,0x54,0x54,0x54,0x20,0x00}, // s
    {0x04,0x3F,0x44,0x40,0x20,0x00}, // t
    {0x3C,0x40,0x40,0x20,0x7C,0x00}, // u
    {0x1C,0x20,0x40,0x20,0x1C,0x00}, // v
    {0x3C,0x40,0x30,0x40,0x3C,0x00}, // w
    {0x44,0x28,0x10,0x28,0x44,0x00}, // x
    {0x0C,0x50,0x50,0x50,0x3C,0x00}, // y
    {0x44,0x64,0x54,0x4C,0x44,0x00}, // z

    /* ASCII 123–127 */
    {0x00,0x08,0x36,0x41,0x00,0x00}, // {
    {0x00,0x00,0x7F,0x00,0x00,0x00}, // |
    {0x00,0x41,0x36,0x08,0x00,0x00}, // }
    {0x08,0x08,0x2A,0x1C,0x08,0x00}, // ~
    {0x00,0x00,0x00,0x00,0x00,0x00}  // DEL
};

/* Send command byte (Control Byte = 0x00) */
static void SSD1306_WriteCommand(uint8_t cmd)
{
    uint8_t data[2] = {0x00, cmd};
    HAL_I2C_Master_Transmit(oled_i2c, SSD1306_ADDR, data, 2, 100);
}

/* Transmit data array safely in 16-byte chunks */
static void SSD1306_WriteData(uint8_t *data, size_t size)
{
    uint8_t buf[17];
    buf[0] = 0x40; // Control Byte = 0x40 (RAM Data)

    for (size_t i = 0; i < size; i += 16) {
        size_t chunk = (size - i > 16) ? 16 : (size - i);
        for (size_t j = 0; j < chunk; j++) {
            buf[j + 1] = data[i + j];
        }
        HAL_I2C_Master_Transmit(oled_i2c, SSD1306_ADDR, buf, chunk + 1, 100);
    }
}

/* Initialize SSD1306 Controller */
void SSD1306_Init(I2C_HandleTypeDef *hi2c)
{
    oled_i2c = hi2c;
    HAL_Delay(100); // Startup delay

    SSD1306_WriteCommand(0xAE); // Display OFF

    SSD1306_WriteCommand(0x20); // Set Memory Addressing Mode
    SSD1306_WriteCommand(0x00); // Horizontal Addressing Mode

    SSD1306_WriteCommand(0x21); // Set Column Address range
    SSD1306_WriteCommand(0x00); // Start = 0
    SSD1306_WriteCommand(0x7F); // End = 127

    SSD1306_WriteCommand(0x22); // Set Page Address range
    SSD1306_WriteCommand(0x00); // Start = 0
    SSD1306_WriteCommand(0x07); // End = 7

    SSD1306_WriteCommand(0x40); // Set Display Start Line to 0
    SSD1306_WriteCommand(0xB0); // Set Page Start Address for Page Addressing Mode

    SSD1306_WriteCommand(0x81); // Set Contrast Control
    SSD1306_WriteCommand(0xFF); // Maximum contrast

    SSD1306_WriteCommand(0xA1); // Set Segment Re-map (0xA0 = left flip, 0xA1 = normal)
    SSD1306_WriteCommand(0xC8); // Set COM Output Scan Direction (0xC0 = top flip, 0xC8 = normal)
    SSD1306_WriteCommand(0xA6); // Normal display mode (0xA7 = inverted)

    SSD1306_WriteCommand(0xA8); // Set Multiplex Ratio
    SSD1306_WriteCommand(0x3F); // 1/64 duty

    SSD1306_WriteCommand(0x8D); // Charge Pump Command
    SSD1306_WriteCommand(0x14); // Enable Charge Pump (0x10 = disable)

    SSD1306_WriteCommand(0xD3); // Set Display Offset
    SSD1306_WriteCommand(0x00); // No offset

    SSD1306_WriteCommand(0xD5); // Set Display Clock Divide Ratio / Oscillator Frequency
    SSD1306_WriteCommand(0x80); // Default ratio

    SSD1306_WriteCommand(0xD9); // Set Pre-charge Period
    SSD1306_WriteCommand(0xF1);

    SSD1306_WriteCommand(0xDA); // Set COM Pins Hardware Configuration
    SSD1306_WriteCommand(0x12);

    SSD1306_WriteCommand(0xDB); // Set VCOMH Deselect Level
    SSD1306_WriteCommand(0x40);

    SSD1306_WriteCommand(0xA4); // Entire Display ON (Resume to RAM content)
    SSD1306_WriteCommand(0xAF); // Display ON

    HAL_Delay(20);
    SSD1306_Clear();
    SSD1306_UpdateScreen();
}

/* Clear internal buffer */
void SSD1306_Clear(void)
{
    memset(SSD1306_Buffer, 0x00, sizeof(SSD1306_Buffer));
    cursorX = 0;
    cursorY = 0;
}

/* Flush local buffer to SSD1306 RAM */
void SSD1306_UpdateScreen(void)
{
    // Reset column and page pointers for full screen update
    SSD1306_WriteCommand(0x21);
    SSD1306_WriteCommand(0x00);
    SSD1306_WriteCommand(0x7F);

    SSD1306_WriteCommand(0x22);
    SSD1306_WriteCommand(0x00);
    SSD1306_WriteCommand(0x07);

    // Send full framebuffer (1024 bytes)
    SSD1306_WriteData(SSD1306_Buffer, sizeof(SSD1306_Buffer));
}

/* Set cursor coordinate */
void SSD1306_SetCursor(uint8_t x, uint8_t y)
{
    cursorX = (x < SSD1306_WIDTH) ? x : (SSD1306_WIDTH - 1);
    cursorY = (y < 8) ? y : 7;
}

/* Write single 6x8 character */
void SSD1306_WriteChar(char ch)
{
    if (ch < 32 || ch > 127) return;

    if (cursorX + 6 > SSD1306_WIDTH) {
        cursorX = 0;
        cursorY++;
    }
    if (cursorY >= 8) return;

    for (uint8_t i = 0; i < 6; i++) {
        SSD1306_Buffer[cursorX + (cursorY * SSD1306_WIDTH)] = Font6x8[ch - 32][i];
        cursorX++;
    }
}

/* Write 6x8 string */
void SSD1306_WriteString(char *str)
{
    while (*str) {
        if (*str == '\n') {
            cursorX = 0;
            cursorY++;
        } else {
            SSD1306_WriteChar(*str);
        }
        str++;
    }
}

/* Write scaled 12x16 character */
void SSD1306_WriteChar_12x16(char ch)
{
    if (ch < 32 || ch > 127) return;

    if (cursorX + 12 > SSD1306_WIDTH) {
        cursorX = 0;
        cursorY += 2;
    }
    if (cursorY + 1 >= 8) return;

    for (uint8_t col = 0; col < 6; col++) {
        uint8_t line = Font6x8[ch - 32][col];

        for (uint8_t bit = 0; bit < 8; bit++) {
            if (line & (1 << bit)) {
                uint16_t x = cursorX + (col * 2);
                uint16_t y = cursorY + (bit >= 4 ? 1 : 0);

                uint8_t bitPos = (bit % 4) * 2;

                SSD1306_Buffer[x + (y * SSD1306_WIDTH)] |= (3 << bitPos);
                SSD1306_Buffer[x + 1 + (y * SSD1306_WIDTH)] |= (3 << bitPos);
            }
        }
    }

    cursorX += 12;
}

/* Write scaled 12x16 string */
void SSD1306_WriteString_12x16(char *str)
{
    while (*str) {
        if (*str == '\n') {
            cursorX = 0;
            cursorY += 2;
        } else {
            SSD1306_WriteChar_12x16(*str);
        }
        str++;
    }
}
